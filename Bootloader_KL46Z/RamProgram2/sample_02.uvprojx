# Keil uVision project sample_02.uvprojx, settings and files
target KL46Z (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sample_02
  c flags: Optim=1 wLevel=2
  asm define: RAM_TARGET
  memory RVCT4: ROM 0x1fffe000 size 0x6000
  memory RVCT9: RAM 0x20004000 size 0x2000
  group Src
    ./: main.c GPIO.c
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
