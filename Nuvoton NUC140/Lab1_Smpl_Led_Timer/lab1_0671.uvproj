# Keil uVision project lab1_0671.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: lab1_0671
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\..\NUC100SeriesBSP;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS file
    ./: startup_NUC1xx.s
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: NUC1xx.h system_NUC1xx.c
  group Resource file
    ../../../Src/NUC1xx-LB_002/: Ascii_Table.C
    ./: lab1_0671.c
  group Library file
    ../../../Src/Driver/: DrvGPIO.c DrvSYS.c
