# Keil uVision project Bootloader_KL46Z.uvprojx, settings and files
target Bootloader_KL46Z (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Bootloader_KL46Z
  c flags: Optim=1 wLevel=2
  c include: .\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x2000
  scatter file: .\Objects\Bootloader_KL46Z.sct
  group Src
    ./: main.c
  group Driver
    ./Source/: UART.c GPIO.c Parse_srec.c
  group Header
    ./Source/: UART.h GPIO.h Parse_srec.h
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
